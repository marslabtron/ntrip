# IAR project ntrip.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x8 ST STM32F030x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030
  ICCARM.CCIncludePath2: C:\Users\Wei\Desktop\ntrip_wei\Libraries\CMSIS\Device\ST\STM32F0xx\Include; C:\Users\Wei\Desktop\ntrip_wei\Libraries\CMSIS\Include; C:\Users\Wei\Desktop\ntrip_wei\Libraries\STM32F0xx_CPAL_Driver\inc; C:\Users\Wei\Desktop\ntrip_wei\Libraries\STM32F0xx_StdPeriph_Driver\inc; C:\Users\Wei\Desktop\ntrip_wei; C:\Users\Wei\Desktop\ntrip_wei\qxwz_sdk_iar_stm32; C:\Users\Wei\Desktop\ntrip_wei\User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ntrip.srec
  ILINK.IlinkOutputFile: ntrip.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: stm32f0xx_it.c
  group CMSIS
    ../Libraries/CMSIS/Include/: core_cm0.h core_cm0plus.h core_cmFunc.h core_cmInstr.h
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
    ../: system_stm32f0xx.c
  group qxwz
    ../qxwz_sdk_iar_stm32/: prefs.h qxwz_rtcm.h rtcm.a socket.h
  group StdPeriph_Lib
    ../Lib/: stm32f0xx.h stm32f0xx_conf.h stm32f0xx_flash.c stm32f0xx_flash.h stm32f0xx_gpio.c stm32f0xx_gpio.h stm32f0xx_misc.c stm32f0xx_misc.h stm32f0xx_rcc.c stm32f0xx_rcc.h stm32f0xx_usart.c stm32f0xx_usart.h
  group User
    ../User/: main.c
